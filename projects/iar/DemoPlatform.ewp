# IAR project DemoPlatform.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F407xx
  ICCARM.CCDiagSuppress: Pa050, Pe047
  ICCARM.CCIncludePath2: ..\..\modules\systick; ..\..\modules\net; ..\..\modules\server; ..\..\modules\utils; ..\..\modules\settings; ..\..\modules\config; ..\..\modules\flash_manager; ..\..\modules\concentrator; ..\..\modules\proto_tcp; ..\..\modules\proto_mqtt; ..\..\modules\adc; ..\..\modules\dac; ..\..\modules\rtc; ..\..\modules\leds; ..\..\modules\periph_watchdog; ..\..\modules\rs485; ..\..\modules\ach_adch; ..\..\modules\ch_dch; ..\..\modules\hood; ..\..\modules\com_handler; ..\..\modules\batteries; ..\..\modules\httpserver-socket; ..\..\stm32\cmsis; ..\..\stm32\spl\inc; ..\..\stm32\ethernet; ..\..\thirdparty\microrl; ..\..\user; ..\..\thirdparty\FreeRTOS\include; ..\..\thirdparty\FreeRTOS\portable\IAR\ARM_CM4F; ..\..\thirdparty\FreeRTOS\CMSIS_RTOS; ..\..\thirdparty\FreeRTOS\wrapper; ..\..\thirdparty\lwip\src\include\; ..\..\thirdparty\lwip\src\include\lwip; ..\..\thirdparty\lwip\src\include\netif\ppp\; ..\..\thirdparty\lwip\src\include\lwip\apps\; ..\..\thirdparty\lwip\system; ..\..\thirdparty\lwip\port\FreeRTOS\; ..\..\thirdparty\json
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\user
  OBJCOPY.OOCOutputFile: DemoPlatform.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group config
    ../../modules/config/: mod_config.h
  group modules/ach_adch
    ../../modules/ach_adch/: ach_adch.cpp
  group modules/adc
    ../../modules/adc/: mcp3422.cpp
  group modules/batteries
    ../../modules/batteries/: batteries.cpp
  group modules/ch_dch
    ../../modules/ch_dch/: ch_dch.cpp
  group modules/com_handler
    ../../modules/com_handler/: com_handler.cpp
  group modules/conсentrator
    ../../modules/concentrator/: concentrator.cpp
  group modules/dac
    ../../modules/dac/: stm32_ub_dac_dma.cpp
  group modules/flash_manager
    ../../modules/flash_manager/: flash_manager.cpp
  group modules/hood
    ../../modules/hood/: hood.cpp
  group modules/httpserver-socket
    ../../modules/httpserver-socket/: httpserver-socket.cpp
  group modules/leds
    ../../modules/leds/: leds.cpp
  group modules/net
    ../../modules/net/: ethernet_bridge.cpp ip_stack.cpp net_bridge.cpp
  group modules/periph_watchdog
    ../../modules/periph_watchdog/: periph_watchdog.cpp
  group modules/proto_mqtt
    ../../modules/proto_mqtt/: proto_mqtt.cpp
  group modules/rs485
    ../../modules/rs485/: rs485.cpp
  group modules/rtc
    ../../modules/rtc/: rtc.cpp
  group modules/settings
    ../../modules/settings/: msens_settings.cpp settings.cpp
  group modules/systick
    ../../modules/systick/: systick.cpp
  group modules/utils
    ../../modules/utils/: commands.cpp thread.cpp tm_stm32f4_id.h
  group stm32/cmsis
    ../../stm32/cmsis/: startup_stm32f4xx.s stm32f4xx.h system_stm32f4xx.c
  group stm32/ethernet
    ../../stm32/ethernet/: stm32f4x7_eth.c stm32f4x7_eth_bsp.c stm32f4x7_eth_conf.h
  group stm32/spl
    ../../stm32/spl/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group thirdparty/freertos
    ../../thirdparty/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
    ../../thirdparty/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../thirdparty/FreeRTOS/MemMang/: heap_4.c
  group thirdparty/freertos/portable
    ../../thirdparty/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group thirdparty/json
    ../../thirdparty/json/: jsmn.c
  group thirdparty/lwip/api
    ../../thirdparty/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group thirdparty/lwip/apps/httpd
    ../../thirdparty/lwip/src/apps/httpd/: fs.c fsdata.c httpd.c
  group thirdparty/lwip/apps/mqtt
    ../../thirdparty/lwip/src/apps/mqtt/: mqtt.c
  group thirdparty/lwip/core
    ../../thirdparty/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group thirdparty/lwip/core/ipv4
    ../../thirdparty/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group thirdparty/lwip/netif
    ../../thirdparty/lwip/src/netif/: ethernet.c slipif.c
  group thirdparty/lwip/port
    ../../thirdparty/lwip/port/FreeRTOS/: ethernetif.c sys_arch.c
  group thirdparty/microrl
    ../../thirdparty/microrl/: microrl.c
  group user
    ../../user/: FreeRTOSConfig.h lwipopts.h main.cpp stm32f4xx_conf.h stm32f4xx_it.c
